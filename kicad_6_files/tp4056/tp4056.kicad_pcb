# Repository facelesstech/tp4056_replacement_PCB

File README.md:

# tp4056_replacement_PCB
tp4056_replacement_PCB

## KiCad design kicad_6_files/tp4056/tp4056.kicad_pcb

Board: 2 copper layers, 23.5 x 16.0 mm, 21 parts (0 on the bottom side), 16 nets.

Parts:
C1: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2, C3: 0.1uF; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1: RED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D2: GREEN; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J4, J5, J6, J7: Conn_01x01_Female; 1mm_test_point_square
P1: USB_C_Plug; USB_C_Receptacle_JAE_DX07S016JA1R1500
R1, R2: 1k; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5: 100; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R6: 0R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R7, R8: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: R; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1: TP4056; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U2: DW01; SOT-23-6_Handsoldering
U4: 8205a; SOT-23-8_Handsoldering_long

Connections:
/G1: U2.1 (OD), U4.4 (G)
/OC: R6.1, U2.2 (CS)
BAT+: C1.1, J6.1, J7.1, R5.1, U1.5 (BAT)
BAT-: C2.2, J4.1, U2.6 (GND), U4.2 (S), U4.3 (S)
GND: C1.2, C3.2, J5.1, P1.A1 (GND), P1.A12 (GND), P1.S1 (SHIELD), R3.2, R6.2, R7.2, R8.2, U1.1 (TEMP), U1.3 (GND), U1.9 (PP), U4.6 (S), U4.7 (S)
unnamed: C2.1, R5.2, U2.5 (VCC)
unnamed: D1.1 (K), R1.1
unnamed: D1.2 (A), D2.2 (A), R9.2
unnamed: D2.1 (K), R2.1
unnamed: P1.A8 (SBU1), R8.1
unnamed: P1.B8 (SBU2), R7.1
unnamed: R1.2, U1.7 (~CHRG)
unnamed: R2.2, U1.6 (~STDBY)
unnamed: R3.1, U1.2 (PROG)
unnamed: U2.3 (OC), U4.5 (G)
VIN: C3.1, P1.A4 (VBUS), P1.A9 (VBUS), R9.1, U1.4 (VCC), U1.8 (CE)

## Commit log

2023-04-11 added license
2023-04-11 added photo
2023-04-11 added PCB files
2023-04-11 added photo fixed
2023-04-11 added photo fixed1
